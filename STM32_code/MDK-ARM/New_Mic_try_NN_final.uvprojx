# Keil uVision project New_Mic_try_NN_final.uvprojx, settings and files
target New_Mic_try_NN_final (6220000::V6.22::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.1
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: New_Mic_try_NN_final +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32U585xx
  c include: ../X-CUBE-AI/App;../X-CUBE-AI;../Core/Inc;../Middlewares/ST/AI/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: New_Mic_try_NN_final.sct
  group Application/MDK-ARM
    ./: startup_stm32u585xx.s
  group Application/User/X-CUBE-AI/App
    ../Core/Src/: PreCulcMFCC.h
    ../X-CUBE-AI/App/: network.c network_data.c network_data_params.c app_x-cube-ai.c
  group Application/User/Core
    ../Core/Src/: retarget.c main.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Doc
    ../X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_sai.c stm32u5xx_hal_sai_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime910_CM33_Keil.lib
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
